FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI += "file://0001-remove-networking-support-set-proper-bootcmd.patch"

